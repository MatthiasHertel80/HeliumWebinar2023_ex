# Keil uVision project BareMetal_LED_Blinky.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: AE722F80F55D5AE:M55_HE Alif Semiconductor
  pack: AlifSemiconductor.Ensemble.0.5.2
  cpu: IRAM(0x02000000,0x00400000) IRAM2(0x08000000,0x00280000) IROM(0x80000000,0x00580000) XRAM(0x50000000,0x00040000) XRAM2(0x50800000,0x00100000) XRAM3(0x60000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: BareMetal_LED_Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c misc: -fvectorize
  memory RVCT4: ROM 0x80000000 size 0x580000
  memory RVCT6: RAM 0x50000000 size 0x40000
  memory RVCT7: RAM 0x50800000 size 0x100000
  memory RVCT8: RAM 0x60000000 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x400000
  memory RVCT10: RAM 0x8000000 size 0x280000
  scatter file: .\RTE\Device\AE722F80F55D5AE_M55_HE\M55_HE.sct
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.4, Device:SOC Peripherals:GPIO 1.0.0, Device:SOC Peripherals:PINCONF 1.0.0, Device:Startup 1.0.0, Compiler:Event Recorder 1.5.1
